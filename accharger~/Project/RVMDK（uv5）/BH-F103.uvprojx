# Keil uVision project BH-F103.uvprojx, settings and files
target Led (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe    --bin   -o   C:\Users\gnr\Documents\工作项目\交流充电桩项目\程序源码\交流桩控制程序-C\工作区\accharger~\Output\App.bin   C:\Users\gnr\Documents\工作项目\交流充电桩项目\程序源码\交流桩控制程序-C\工作区\accharger~\Output\流水灯.axf
  c flags: Optim=1 oTime=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\led;..\..\User\GeneralTim
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group USER
    ../../User/usart/: bsp_usart.c
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Led/: bsp_led.c
    ../../User/GeneralTim/: bsp_GeneralTim.c bsp_GeneralTim.h
    ../../User/led/: bsp_led.h
    ../../User/meter/: elec_meter.c elec_meter.h
    ../../User/internal_flash/: bsp_internal_flash.c bsp_internal_flash.h
    ../../User/485/: bsp_485.c bsp_485.h
    ../../User/EXTI/: bsp_exti.c bsp_exti.h
    ../../User/wwdg/: bsp_wwdg.c bsp_wwdg.h
    ../../User/iwdg/: bsp_iwdg.c bsp_iwdg.h
    ../../User/SysTick/: bsp_SysTick.c bsp_SysTick.h
    ../../User/dlt645_07/: dlt645_07_api.c dlt645_07_api.h
    ../../User/b232/: bsp_232.c bsp_232.h
  group DOC
    ../../Doc/: readme.txt
  group FWlib
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
